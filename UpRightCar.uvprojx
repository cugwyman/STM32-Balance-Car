# Keil uVision project UpRightCar.uvprojx, settings and files
target NXPSmartCar (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK60DN512xxx10 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: UpRightCar
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MK60D10
  c include: .\Libraries\devices\inc;.\Libraries\drivers\K\inc;.\Libraries\startup\CoreSupport;.\Libraries\startup\DeviceSupport;.\User\inc;.\Debug\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Startup
    ./Libraries/startup/DeviceSupport/: system_MK60D10.c startup_MK60D10.s
  group Drivers
    ./Libraries/drivers/K/src/: adc.c common.c ftm.c gpio.c i2c.c pit.c systick.c uart.c dac.c dma.c flash.c lptmr.c
    ./Debug/src/: asc12.c asc16.c hz12.c hz16.c
  group Devices
    ./Libraries/devices/src/: Encoder.c Motor.c
  group User
    ./User/src/: Main.c BorderSearchRelative.c DataComm.c ImgProc.c ImgUtility.c MainProc.c MathPropertiesAnalyze.c PatternMatch.c Angle.c Direction.c Velocity.c Fuzzy.c MPU6050.c
  group Documents
    ./Documents/: ReadMe.txt
    ./User/inc/: PinMap.h Param.h TypeDef.h Config.h ImgUtility.h
  group Debug
    ./Debug/src/: OLED.c oledbase.c
    ./User/src/: Joystick.c
