# Keil uVision project BalanceCar.uvprojx, settings and files
target BalanceCar (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BalanceCar +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050;..\USMART;..\HARDWARE\MOTOR;..\HARDWARE\ENCODER;..\DOCUMENTS;..\HARDWARE\TIMER;..\HARDWARE\CONTROL;..\HARDWARE\MODESWITCH;..\HARDWARE\OLED;..\HARDWARE\INFRARED;..\HARDWARE\OscilloScope;..\HARDWARE\KEY4x4;..\HARDWARE\EXTI;..\HARDWARE\IDENTIFY
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MPU6050/: mpuiic.c mpu6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MOTOR/: pwm.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/CONTROL/: control.c
    ./: mode_switch.c
    ../HARDWARE/OLED/: OLED.c
    ../HARDWARE/INFRARED/: infrared.c
    ../HARDWARE/OscilloScope/: OscilloScope.c
    ../HARDWARE/KEY4x4/: key4x4.c
    ../HARDWARE/EXTI/: EXTI.c
    ../HARDWARE/IDENTIFY/: road_identify.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c
  group DOCUMENTS
    ../DOCUMENTS/: Param.h README.txt Config.h TypeDef.h
